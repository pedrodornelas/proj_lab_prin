options:
  parameters:
    author: lucas
    generate_options: qt_gui
    id: projeto
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: An
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.1'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: '10'
  states: {}
- name: ganho
  id: variable
  parameters:
    value: '200'
  states: {}
- name: radio
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '4'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0.5'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: An
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_1_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '65000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '95000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1_2_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 35000+(radio*15000)
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1_3_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '80000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1_3_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '50000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_1_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/ganho
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ganho
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ganho
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ganho
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ganho
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_2_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_2_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_2_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_2_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0_0_1_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0_1_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0_1_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0_1_0_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0_2_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_2_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_2_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_2_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0_1
  id: blocks_wavfile_source
  parameters:
    file: /home/pedro/Documentos/UnB/5_Semestre/Lab_princom/proj_lab_prin/FurElise.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_1_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pedro/Documentos/UnB/5_Semestre/Lab_princom/proj_lab_prin/Nocturne.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_1_1
  id: blocks_wavfile_source
  parameters:
    file: /home/pedro/Documentos/UnB/5_Semestre/Lab_princom/proj_lab_prin/RondoAllaTurca.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_1_2
  id: blocks_wavfile_source
  parameters:
    file: /home/pedro/Documentos/UnB/5_Semestre/Lab_princom/proj_lab_prin/5th_Symphony.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0_0_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '7000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_1_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '7000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_1_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '7000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_1_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '7000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '7000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Analisador de Espectro - Canal
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Analisador de Espectro - Receptor
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: Receptor
    name: Osciloscópio
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '6'
    ymin: '-6'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: canal
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: radio1
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: porta1
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: porta2
  states: {}
- name: virtual_sink_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: porta3
  states: {}
- name: virtual_sink_1_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: porta4
  states: {}
- name: virtual_sink_1_1
  id: virtual_sink
  parameters:
    stream_id: radio2
  states: {}
- name: virtual_sink_1_1_0
  id: virtual_sink
  parameters:
    stream_id: radio3
  states: {}
- name: virtual_sink_1_1_0_0
  id: virtual_sink
  parameters:
    stream_id: radio4
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: ruido
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: canal
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: radio1
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: porta1
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: porta2
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: porta3
  states: {}
- name: virtual_source_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: porta4
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: radio2
  states: {}
- name: virtual_source_1_1_0
  id: virtual_source
  parameters:
    stream_id: radio3
  states: {}
- name: virtual_source_1_1_0_0
  id: virtual_source
  parameters:
    stream_id: radio4
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: ruido
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0_2_0, '0']
- [analog_sig_source_x_0_1_0_0_0, '0', blocks_throttle_0_0_1_0_0, '0']
- [analog_sig_source_x_0_1_0_0_0_0, '0', blocks_throttle_0_0_1_0_0_0, '0']
- [analog_sig_source_x_0_1_2_0_0, '0', blocks_multiply_xx_0_0_0_0_0, '1']
- [analog_sig_source_x_0_1_3_0_0, '0', blocks_throttle_0_0_1_0_0_1, '0']
- [analog_sig_source_x_0_1_3_0_1, '0', blocks_throttle_0_0_0_1_0_0, '0']
- [blocks_add_xx_0_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0_0_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_1_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', virtual_sink_1, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', virtual_sink_1_1, '0']
- [blocks_multiply_const_vxx_0_0_0_0_0, '0', virtual_sink_1_1_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0_0_0, '0', virtual_sink_1_1_0_0, '0']
- [blocks_multiply_xx_0_0_0_0_0, '0', low_pass_filter_0_1_0_0, '0']
- [blocks_multiply_xx_0_2_0_0, '0', blocks_add_xx_0_0_0, '1']
- [blocks_multiply_xx_0_2_0_0_0, '0', blocks_add_xx_0_0_0, '2']
- [blocks_multiply_xx_0_2_0_0_0_0, '0', blocks_add_xx_0_0_0, '3']
- [blocks_multiply_xx_0_2_0_0_1, '0', blocks_add_xx_0_0_0, '0']
- [blocks_throttle_0, '0', virtual_sink_2, '0']
- [blocks_throttle_0_0_0_1_0_0, '0', virtual_sink_1_0, '0']
- [blocks_throttle_0_0_1_0_0, '0', virtual_sink_1_0_0, '0']
- [blocks_throttle_0_0_1_0_0_0, '0', virtual_sink_1_0_0_0_0, '0']
- [blocks_throttle_0_0_1_0_0_1, '0', virtual_sink_1_0_0_0, '0']
- [blocks_throttle_0_0_2_0, '0', low_pass_filter_0_0_1_0_0_0, '0']
- [blocks_throttle_0_2_0, '0', low_pass_filter_0_0_1_0, '0']
- [blocks_throttle_0_2_0_0, '0', low_pass_filter_0_0_1_0_0, '0']
- [blocks_throttle_0_2_0_1, '0', low_pass_filter_0_0_1_0_1, '0']
- [blocks_wavfile_source_0_1, '0', blocks_throttle_0_2_0_0, '0']
- [blocks_wavfile_source_0_1_0, '0', blocks_throttle_0_2_0_1, '0']
- [blocks_wavfile_source_0_1_1, '0', blocks_throttle_0_0_2_0, '0']
- [blocks_wavfile_source_0_1_2, '0', blocks_throttle_0_2_0, '0']
- [low_pass_filter_0_0_1_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [low_pass_filter_0_0_1_0_0, '0', blocks_multiply_const_vxx_0_0_0_0_0, '0']
- [low_pass_filter_0_0_1_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [low_pass_filter_0_0_1_0_1, '0', blocks_multiply_const_vxx_0_0_0_0_0_0, '0']
- [low_pass_filter_0_1_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0_0_0_0_0, '0']
- [virtual_source_1, '0', blocks_multiply_xx_0_2_0_0_1, '0']
- [virtual_source_1_0, '0', blocks_multiply_xx_0_2_0_0_1, '1']
- [virtual_source_1_0_0, '0', blocks_multiply_xx_0_2_0_0, '1']
- [virtual_source_1_0_0_0, '0', blocks_multiply_xx_0_2_0_0_0, '1']
- [virtual_source_1_0_0_0_0, '0', blocks_multiply_xx_0_2_0_0_0_0, '1']
- [virtual_source_1_1, '0', blocks_multiply_xx_0_2_0_0, '0']
- [virtual_source_1_1_0, '0', blocks_multiply_xx_0_2_0_0_0, '0']
- [virtual_source_1_1_0_0, '0', blocks_multiply_xx_0_2_0_0_0_0, '0']
- [virtual_source_2, '0', blocks_add_xx_0_0_0, '4']

metadata:
  file_format: 1
