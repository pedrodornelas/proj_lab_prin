options:
  parameters:
    author: lucas
    generate_options: qt_gui
    id: projeto
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: An
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0'
  states: {}
- name: cut
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '100'
    stop: '14000'
    value: '4000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '100'
    stop: '1000'
    value: '700'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.141592654'
  states: {}
- name: radio
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '4'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '30'
    value: '1'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: An
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_pll_refout_cc_0_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: 2*pi*(90002000/samp_rate)
    min_freq: 2*pi*(89998000/samp_rate)
    w: pi/50
  states: {state: disabled}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '-1'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '60000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '80000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1_2_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 40000+(radio*10000)
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1_2_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: '190000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_1_2_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_1_2_0_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: '160000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_1_3_0_0
  id: analog_sig_source_x
  parameters:
    amp: '5'
    freq: '70000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1_3_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '50000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_3_0_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: freq
    offset: '-1'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_1_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0_0_0_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0_0_0_0_0_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0_2_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0_2_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_2_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_2_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_2_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0_0_1_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0_1_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0_1_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0_1_0_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0_2_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_2_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_2_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_2_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: 2000*pi
  states: {state: disabled}
- name: blocks_wavfile_source_0_1
  id: blocks_wavfile_source
  parameters:
    file: /home/pedro/Documentos/UnB/5_Semestre/Lab_princom/proj_lab_prin/5th_Symphony.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_1_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pedro/Documentos/UnB/5_Semestre/Lab_princom/proj_lab_prin/RondoAllaTurca.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0_0_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '4000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_1_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '4000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_1_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '4000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_1_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '4000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_1_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: cut
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_1_0_0_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_1_0_0_2
  id: low_pass_filter
  parameters:
    cutoff_freq: cut
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Analisador de Espectro
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Analisador de Espectro
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '6'
    ymin: '-6'
  states: {}
- name: qtgui_time_sink_x_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0_1_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '6'
    ymin: '-6'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: canal
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: radio1
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: porta1
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: porta2
  states: {}
- name: virtual_sink_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: porta3
  states: {}
- name: virtual_sink_1_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: porta4
  states: {}
- name: virtual_sink_1_1
  id: virtual_sink
  parameters:
    stream_id: radio2
  states: {}
- name: virtual_sink_1_1_0
  id: virtual_sink
  parameters:
    stream_id: radio3
  states: {}
- name: virtual_sink_1_1_0_0
  id: virtual_sink
  parameters:
    stream_id: radio4
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: ruido
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: canal
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: canal
  states: {state: disabled}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: canal
  states: {state: disabled}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: canal
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: radio1
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: porta1
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: porta2
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: porta3
  states: {}
- name: virtual_source_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: porta4
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: radio2
  states: {}
- name: virtual_source_1_1_0
  id: virtual_source
  parameters:
    stream_id: radio3
  states: {}
- name: virtual_source_1_1_0_0
  id: virtual_source
  parameters:
    stream_id: radio4
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: ruido
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_throttle_0, '0']
- [analog_pll_refout_cc_0_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0_0_0, '0', blocks_throttle_0_0_2_0, '0']
- [analog_sig_source_x_0_1_0_0_0, '0', blocks_throttle_0_0_1_0_0, '0']
- [analog_sig_source_x_0_1_0_0_0_0, '0', blocks_throttle_0_0_1_0_0_0, '0']
- [analog_sig_source_x_0_1_2_0_0, '0', blocks_multiply_xx_0_0_0_0_0, '1']
- [analog_sig_source_x_0_1_2_0_0_0, '0', blocks_multiply_xx_0_0_0_0_0_0, '1']
- [analog_sig_source_x_0_1_2_0_0_1, '0', blocks_multiply_xx_0_0_0_0_0_1, '1']
- [analog_sig_source_x_0_1_2_0_0_1_0, '0', blocks_multiply_xx_0_0_0_0_0_1_0, '1']
- [analog_sig_source_x_0_1_3_0_0, '0', blocks_throttle_0_0_1_0_0_1, '0']
- [analog_sig_source_x_0_1_3_0_1, '0', blocks_throttle_0_0_0_1_0_0, '0']
- [analog_sig_source_x_0_3_0_0, '0', blocks_throttle_0_2_0_0, '0']
- [blocks_add_xx_0_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0_0_0, '0', virtual_sink_0, '0']
- [blocks_complex_to_real_0, '0', low_pass_filter_0_1_0_0_2, '0']
- [blocks_complex_to_real_0_0, '0', blocks_multiply_xx_0_2_0, '0']
- [blocks_float_to_complex_0, '0', analog_pll_refout_cc_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0_1_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_xx_0_0_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_xx_0_0_0_0_0_0, '0', low_pass_filter_0_1_0_0_0, '0']
- [blocks_multiply_xx_0_0_0_0_0_1, '0', low_pass_filter_0_1_0_0_1, '0']
- [blocks_multiply_xx_0_0_0_0_0_1_0, '0', low_pass_filter_0_1_0_0_1_0, '0']
- [blocks_multiply_xx_0_2_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_xx_0_2_0_0, '0', blocks_add_xx_0_0_0, '1']
- [blocks_multiply_xx_0_2_0_0_0, '0', blocks_add_xx_0_0_0, '2']
- [blocks_multiply_xx_0_2_0_0_0_0, '0', blocks_add_xx_0_0_0, '3']
- [blocks_multiply_xx_0_2_0_0_1, '0', blocks_add_xx_0_0_0, '0']
- [blocks_throttle_0, '0', virtual_sink_2, '0']
- [blocks_throttle_0_0_0_1_0_0, '0', virtual_sink_1_0, '0']
- [blocks_throttle_0_0_1_0_0, '0', virtual_sink_1_0_0, '0']
- [blocks_throttle_0_0_1_0_0_0, '0', virtual_sink_1_0_0_0_0, '0']
- [blocks_throttle_0_0_1_0_0_1, '0', virtual_sink_1_0_0_0, '0']
- [blocks_throttle_0_0_2_0, '0', low_pass_filter_0_0_1_0_0_0, '0']
- [blocks_throttle_0_2_0, '0', low_pass_filter_0_0_1_0, '0']
- [blocks_throttle_0_2_0_0, '0', low_pass_filter_0_0_1_0_0, '0']
- [blocks_throttle_0_2_0_1, '0', low_pass_filter_0_0_1_0_1, '0']
- [blocks_vco_c_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_wavfile_source_0_1, '0', blocks_throttle_0_2_0, '0']
- [blocks_wavfile_source_0_1_0, '0', blocks_throttle_0_2_0_1, '0']
- [low_pass_filter_0_0_1_0, '0', virtual_sink_1, '0']
- [low_pass_filter_0_0_1_0_0, '0', virtual_sink_1_1_0, '0']
- [low_pass_filter_0_0_1_0_0_0, '0', virtual_sink_1_1, '0']
- [low_pass_filter_0_0_1_0_1, '0', virtual_sink_1_1_0_0, '0']
- [low_pass_filter_0_1_0_0, '0', audio_sink_1_0, '0']
- [low_pass_filter_0_1_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0_1_0_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [low_pass_filter_0_1_0_0_0, '0', qtgui_time_sink_x_0_1_0_0, '0']
- [low_pass_filter_0_1_0_0_1, '0', qtgui_time_sink_x_0_1_0_1, '0']
- [low_pass_filter_0_1_0_0_1_0, '0', qtgui_time_sink_x_0_1_0_1_0, '0']
- [low_pass_filter_0_1_0_0_2, '0', qtgui_time_sink_x_0_1_0_2, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0_0_0_0_0, '0']
- [virtual_source_0_0, '0', blocks_multiply_xx_0_0_0_0_0_0, '0']
- [virtual_source_0_1, '0', blocks_multiply_xx_0_0_0_0_0_1, '0']
- [virtual_source_0_1_0, '0', blocks_multiply_xx_0_0_0_0_0_1_0, '0']
- [virtual_source_1, '0', blocks_multiply_xx_0_2_0_0_1, '0']
- [virtual_source_1_0, '0', blocks_multiply_xx_0_2_0_0_1, '1']
- [virtual_source_1_0_0, '0', blocks_multiply_xx_0_2_0_0, '1']
- [virtual_source_1_0_0_0, '0', blocks_multiply_xx_0_2_0_0_0, '1']
- [virtual_source_1_0_0_0_0, '0', blocks_multiply_xx_0_2_0_0_0_0, '1']
- [virtual_source_1_1, '0', blocks_multiply_xx_0_2_0_0, '0']
- [virtual_source_1_1_0, '0', blocks_multiply_xx_0_2_0_0_0, '0']
- [virtual_source_1_1_0_0, '0', blocks_multiply_xx_0_2_0_0_0_0, '0']
- [virtual_source_2, '0', blocks_add_xx_0_0_0, '4']

metadata:
  file_format: 1
